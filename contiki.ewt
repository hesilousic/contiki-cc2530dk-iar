<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>blink hello</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>udp client</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>udp server</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>core</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\dev\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\dev\serial-line.c</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\lib\ringbuf.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>mac</name>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\contikimac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\csma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\cxmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\frame802154.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\framer-802154.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\framer-nullmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\lpp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\mac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\nullmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\nullrdc-noframer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\nullrdc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\phase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\sicslowmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\mac\xmac.c</name>
        </file>
      </group>
      <group>
        <name>rime</name>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\abc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\announcement.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\broadcast-announcement.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\broadcast.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\chameleon-bitopt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\chameleon-raw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\chameleon.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\channel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\collect-link-estimate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\collect-neighbor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\collect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\ipolite.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\mesh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\multihop.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\neighbor-discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\netflood.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\polite-announcement.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\polite.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rimeaddr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rimestats.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rmh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\route-discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\route.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rucb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rudolph0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rudolph1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\rudolph2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\runicast.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\stbroadcast.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\stunicast.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\timesynch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\trickle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rime\unicast.c</name>
        </file>
      </group>
      <group>
        <name>rpl</name>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-dag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-ext-header.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-icmp6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-mrhof.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-of0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl-timers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\contiki-2.7\core\net\rpl\rpl.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\dhcpc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\hc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\nbr-table.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\netstack.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\packetbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\packetqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\psock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\queuebuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\resolv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\sicslowpan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\simple-udp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\slipdev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\tcpdump.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\tcpip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uaodv-rt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uaodv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-ds6-nbr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-ds6-route.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-ds6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-fw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-icmp6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-nd6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-neighbor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-over-mesh.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-packetqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-split.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip-udp-packet.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uip_arp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\net\uiplib.c</name>
      </file>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\profile.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\timetable-aggregate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\core\sys\timetable.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>cpu</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\cc2530-rf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\dma_intr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\uart-intr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\uart0.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\uart1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\dev\watchdog.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\rtimer-arch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\cpu\cc253x\soc.c</name>
    </file>
  </group>
  <group>
    <name>example</name>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\examples\cc2530dk\blink-hello.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\examples\cc2530dk\udp-ipv6\client.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\examples\cc2530dk\hello-world.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\examples\cc2530dk\udp-ipv6\ping6.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\examples\cc2530dk\udp-ipv6\server.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\examples\cc2530dk\timer-test.c</name>
    </file>
  </group>
  <group>
    <name>platform</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\contiki-2.7\platform\cc2530dk\dev\leds-arch.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\platform\cc2530dk\contiki-main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\platform\cc2530dk\debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\platform\cc2530dk\putchar.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\contiki-2.7\platform\cc2530dk\uip-debug.c</name>
    </file>
  </group>
</project>


