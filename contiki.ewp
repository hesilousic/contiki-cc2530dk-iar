# IAR project contiki.ewp, settings and files
configuration blink hello (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: VP_CONFIG_H="contiki-conf.h"; VP_NASSERT; UIP_CONF_IPV6=1; UIP_CONF_ICMP6=1; UIP_CONF_BYTE_ORDER=UIP_LITTLE_ENDIAN; AUTOSTART_ENABLE=1
  ICC8051.CCDiagSuppress: pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: contiki-2.7\cpu\cc253x_iar; contiki-2.7\core; contiki-2.7\platform\cc2530dk_iar
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration udp client (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: VP_CONFIG_H="contiki-conf.h"; VP_NASSERT; UIP_CONF_IPV6=1; UIP_CONF_ICMP6=1; UIP_CONF_BYTE_ORDER=UIP_LITTLE_ENDIAN; AUTOSTART_ENABLE=1; ADC_SENSOR_ON=0; BUTTON_SENSOR_ON=0
configuration udp server (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: VP_CONFIG_H="contiki-conf.h"; VP_NASSERT; UIP_CONF_IPV6=1; UIP_CONF_ICMP6=1; UIP_CONF_BYTE_ORDER=UIP_LITTLE_ENDIAN; AUTOSTART_ENABLE=1; BUTTON_SENSOR_ON=0; ADC_SENSOR_ON=0
  group core/dev
    contiki-2.7/core/dev/: leds.c serial-line.c
  group core/lib
    contiki-2.7/core/lib/: list.c memb.c ringbuf.c
  group core/net
    contiki-2.7/core/net/: dhcpc.c hc.c nbr-table.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    contiki-2.7/core/net/mac/: contikimac.c csma.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c xmac.c
  group core/net/rime
    contiki-2.7/core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon-raw.c chameleon.c channel.c collect-link-estimate.c collect-neighbor.c collect.c ipolite.c mesh.c multihop.c neighbor-discovery.c netflood.c polite-announcement.c polite.c rimeaddr.c rimestats.c rmh.c route-discovery.c route.c rucb.c rudolph0.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group core/net/rpl
    contiki-2.7/core/net/rpl/: rpl-conf.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group core/sys
    contiki-2.7/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group cpu
    contiki-2.7/cpu/cc253x_iar/: rtimer-arch.c soc.c
  group cpu/dev
    contiki-2.7/cpu/cc253x_iar/dev/: cc2530-rf.c clock.c dma.c dma_intr.c random.c uart-intr.c uart0.c uart1.c watchdog.c
  group example
    contiki-2.7/examples/cc2530dk/: blink-hello.c hello-world.c timer-test.c
    contiki-2.7/examples/cc2530dk/udp-ipv6/: client.c ping6.c server.c
  group platform
    contiki-2.7/platform/cc2530dk_iar/: contiki-main.c debug.c putchar.c uip-debug.c
  group platform/dev
    contiki-2.7/platform/cc2530dk_iar/dev/: leds-arch.c
